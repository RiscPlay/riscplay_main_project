    .section .text
    .globl _start

_start:

# --------------------------------------------------
# Teste MUL
# 7 * 9 = 63
# --------------------------------------------------
    li      t0, 7
    li      t1, 9
    mul     t2, t0, t1
    li      t3, 63
    bne     t2, t3, fail


# --------------------------------------------------
# Teste MUL
# 7 * 9 = -63
# --------------------------------------------------
    li      t0, 7
    li      t1, -9
    mul     t2, t0, t1
    li      t3, -63
    bne     t2, t3, fail


# --------------------------------------------------
# Teste MUL
# 7 * 9 = 63
# --------------------------------------------------
    li      t0, -7
    li      t1, -9
    mul     t2, t0, t1
    li      t3, 63
    bne     t2, t3, fail


# --------------------------------------------------
# Teste MUL
# 7 * 9 = -63
# --------------------------------------------------
    li      t0, -7
    li      t1, 9
    mul     t2, t0, t1
    li      t3, -63
    bne     t2, t3, fail

# --------------------------------------------------
# Teste MULH
# 0x40000000 * 4 = 0x00000001_00000000
# Parte alta assinada = 1
# --------------------------------------------------
    li      t0, 0x40000000
    li      t1, -4
    mulh    t2, t0, t1
    li      t3, -1
    bne     t2, t3, fail

# --------------------------------------------------
# Teste MULHU
# --------------------------------------------------
    li      t0, -1          # 0xffffffff
    li      t1, 2
    mulhu   t2, t0, t1
    li      t3, 1
    bne     t2, t3, fail

# --------------------------------------------------
# Teste MULHSU
# (-2 * 2) = 0xfffffffffffffffc
# parte alta = 0xffffffff
# --------------------------------------------------
    li      t0, -2
    li      t1, 2
    mulhsu  t2, t0, t1
    li      t3, -1
    bne     t2, t3, fail

# --------------------------------------------------
# Teste DIV
# 100 / 7 = 14
# --------------------------------------------------
    li      t0, 100
    li      t1, 7
    div     t2, t0, t1
    li      t3, 14
    bne     t2, t3, fail


# --------------------------------------------------
# Teste DIV
# 100 / -7 = -14
# --------------------------------------------------
    li      t0, 100
    li      t1, -7
    div     t2, t0, t1
    li      t3, -14
    bne     t2, t3, fail


# --------------------------------------------------
# Teste DIV
# 100 / -7 = 14
# --------------------------------------------------
    li      t0, -100
    li      t1, 7
    div     t2, t0, t1
    li      t3, -14
    bne     t2, t3, fail


# --------------------------------------------------
# Teste DIV
# -100 / -7 = 14
# --------------------------------------------------
    li      t0, -100
    li      t1, -7
    div     t2, t0, t1
    li      t3, 14
    bne     t2, t3, fail

# --------------------------------------------------
# Teste REM
# 100 % 7 = 2
# --------------------------------------------------
    li      t0, 100
    li      t1, 7
    rem     t2, t0, t1
    li      t3, 2
    bne     t2, t3, fail

# --------------------------------------------------
# Teste REM
# 100 % -7 = 2
# --------------------------------------------------
    li      t0, 100
    li      t1, -7
    rem     t2, t0, t1
    li      t3, 2
    bne     t2, t3, fail

# --------------------------------------------------
# Teste REM
# -100 % 7 = -2
# --------------------------------------------------
    li      t0, -100
    li      t1, 7
    rem     t2, t0, t1
    li      t3, -2
    bne     t2, t3, fail

# --------------------------------------------------
# Teste DIVU
# 100 / 9 = 11
# --------------------------------------------------
    li      t0, 100
    li      t1, 9
    divu    t2, t0, t1
    li      t3, 11
    bne     t2, t3, fail

# --------------------------------------------------
# Teste REMU
# 100 % 9 = 1
# --------------------------------------------------
    remu    t2, t0, t1
    li      t3, 1
    bne     t2, t3, fail

# --------------------------------------------------
# SUCESSO
# escreve 0x11001100 em 0x100
# --------------------------------------------------
success:
    li      t0, 0x100
    li      t1, 0x11001100
    sw      t1, 0(t0)

hang:
    j       hang

# --------------------------------------------------
# FALHA
# escreve 0xFF00FF00 em 0x104
# --------------------------------------------------
fail:
    li      t0, 0x104
    li      t1, 0xFF00FF00
    sw      t1, 0(t0)

fail_hang:
    j       fail_hang